# Keil uVision project MyProject.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: MyProject
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\2_Tutorial Keil Projects\0_Library\CMSIS\Include;..\..\..\2_Tutorial Keil Projects\0_Library\NUC1xx-LB_002\Include;..\..\..\2_Tutorial Keil Projects\0_Library\NUC100Series\Include;..\..\..\2_Tutorial Keil Projects\0_Library\NuMakerLib\Include;..\..\..\2_Tutorial Keil Projects\0_Library\StdDriver\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group System Source
    ../../../2_Tutorial Keil Projects/0_Library/NUC100Series/Source/: system_NUC100Series.c
    ../../../2_Tutorial Keil Projects/0_Library/NUC100Series/Source/ARM/: startup_NUC100Series.s
    ../../../2_Tutorial Keil Projects/0_Library/StdDriver/Source/: spi.c clk.c gpio.c
    ../../../2_Tutorial Keil Projects/0_Library/NUC1xx-LB_002/Source/: LCD.c
    ../../../2_Tutorial Keil Projects/0_Library/NuMakerLib/Source/: Draw2D.c
  group User Source
    ./: main.c
  group User Header
    ./: picture.h
